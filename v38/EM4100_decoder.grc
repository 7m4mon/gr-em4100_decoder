options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: input_sample_per_bit/decode_sample_per_bit
  states: {}
- name: decode_sample_per_bit
  id: variable
  parameters:
    value: '16'
  states: {}
- name: input_sample_per_bit
  id: variable
  parameters:
    value: samp_rate*512/1000000
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: int(decimation)
    audio_pass: '20000'
    audio_stop: '30000'
    chan_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/nomurah/gr-em4100_decoder/ao125k_sqcoil_tag_1Msps_R2.flt
    repeat: 'False'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: em4100_decoder_em4100_decoder_b_0
  id: em4100_decoder_em4100_decoder_b
  parameters:
    bit_sync_num: '9'
    sample_per_bit: decode_sample_per_bit
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/decimation
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '256'
    srate: samp_rate/decimation
    type: float
    ymax: '0.01'
    ymin: '-0.01'
  states: {}

connections:
- [analog_am_demod_cf_0, '0', high_pass_filter_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', analog_am_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_float_to_complex_0, '0']
- [digital_binary_slicer_fb_0, '0', em4100_decoder_em4100_decoder_b_0, '0']
- [high_pass_filter_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
